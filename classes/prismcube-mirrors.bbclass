PREMIRRORS_append () {
cvs://.*/.* https://prismcube.github.io/archive/
svn://.*/.* https://prismcube.github.io/archive/
git://.*/.* https://prismcube.github.io/archive/
hg://.*/.*  https://prismcube.github.io/archive/
bzr://.*/.* https://prismcube.github.io/archive/
osc://.*/.* https://prismcube.github.io/archive/
p4://.*/.*  https://prismcube.github.io/archive/
svk://.*/.* https://prismcube.github.io/archive/
}

MIRRORS_append () {
ftp://.*/.*	https://prismcube.github.io/archive/
https?$://.*/.*	https://prismcube.github.io/archive/
}
